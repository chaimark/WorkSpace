# Keil uVision project WIFI.uvprojx, settings and files
target Example (5040049::V5.04 update 1 (build 49)::ARMCC)
  device: FM33LC02X FMSH
  pack: FMSH.FM33LC0XX_DFP.3.0.3
  cpu: IRAM(0x20000000,0x6000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Double_ANI_LoRa_GetWay +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: FM33LC0XX,USE_FULL_ASSERT
  c include: ..\Drivers\CMSIS\Inculde;..\Drivers\FM33LC0xx_LL_Driver\Inc;..\Drivers\CMSIS\Device\FM\FM33xx\Include;..\MF-config\Inc;..\Inc;..\HTTP_Ser
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group Drivers/FM33LC0xx_LL_Driver
    ../Drivers/FM33LC0xx_LL_Driver/Src/: fm33lc0xx_ll_adc.c fm33lc0xx_ll_aes.c fm33lc0xx_ll_atim.c fm33lc0xx_ll_bstim.c fm33lc0xx_ll_comp.c fm33lc0xx_ll_crc.c fm33lc0xx_ll_dma.c fm33lc0xx_ll_flash.c fm33lc0xx_ll_gpio.c fm33lc0xx_ll_gptim.c fm33lc0xx_ll_hdiv.c fm33lc0xx_ll_i2c.c fm33lc0xx_ll_iwdt.c fm33lc0xx_ll_lcd.c fm33lc0xx_ll_lptim.c fm33lc0xx_ll_lpuart.c fm33lc0xx_ll_opa.c fm33lc0xx_ll_pmu.c fm33lc0xx_ll_rcc.c fm33lc0xx_ll_rng.c fm33lc0xx_ll_rtc.c fm33lc0xx_ll_spi.c fm33lc0xx_ll_svd.c fm33lc0xx_ll_u7816.c fm33lc0xx_ll_uart.c fm33lc0xx_ll_wwdt.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/FM/FM33xx/Source/Templates/ARM/: startup_fm33lc0xx.s
    ../Drivers/CMSIS/Device/FM/FM33xx/Source/: system_fm33lc0xx.c
  group HTTP_Ser
    ../HTTP_Ser/: HtmlCode.h HttpApp.c HttpApp.h import_Wifi_DATA.c import_Wifi_DATA.h NumberBaseLic.c NumberBaseLic.h StrLib.c StrLib.h WifiTask.c WifiTask.h AcceptAnalyze.c AcceptAnalyze.h RunComputerCmd.c RunComputerCmd.h JsonApp.c JsonApp.h
  group MF-config
    ../MF-config/Src/: mf_config.c
  group User
    ../Src/: main.c RTC.c Uart.c Sleep.c WakeUp.c Flash.c LPUart.c LPTim.c IWDT.c GPIO_Interrupt.c BSTim.c User_Init.c Define.c w600_wifi.c w600_wifi.h protocol.c protocol.h
