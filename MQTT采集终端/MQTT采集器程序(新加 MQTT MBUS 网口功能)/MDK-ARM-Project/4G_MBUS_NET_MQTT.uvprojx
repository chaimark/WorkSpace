# Keil uVision project 4G_MBUS_NET_MQTT.uvprojx, settings and files
target 4G_MBUS_NET_MQTT (5040049::V5.04 update 1 (build 49)::ARMCC)
  device: FM33LC04X FMSH
  pack: FMSH.FM33LC0XX_DFP.3.0.3
  cpu: IRAM(0x20000000,0x6000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: 4G_MQTT_MBUS +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: FM33LC0XX,USE_FULL_ASSERT,MFANG
  c include: ..\Drivers\FM33LC0xx_FL_Driver\Inc;..\Drivers\CMSIS\Device\FM\FM33xx\Include;..\MF-config;..\User;..\Interflow
  memory RVCT4: ROM 0x4000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/FM/FM33xx/Source/: system_fm33lc0xx.c
  group Drivers/FM33LC0xx_FL_Driver
    ../Drivers/FM33LC0xx_FL_Driver/Src/: fm33lc0xx_fl_adc.c fm33lc0xx_fl_aes.c fm33lc0xx_fl_atim.c fm33lc0xx_fl_bstim32.c fm33lc0xx_fl_comp.c fm33lc0xx_fl_crc.c fm33lc0xx_fl_dma.c fm33lc0xx_fl_flash.c fm33lc0xx_fl_gpio.c fm33lc0xx_fl_gptim.c fm33lc0xx_fl_divas.c fm33lc0xx_fl_i2c.c fm33lc0xx_fl_iwdt.c fm33lc0xx_fl_lptim32.c fm33lc0xx_fl_lpuart.c fm33lc0xx_fl_opa.c fm33lc0xx_fl_pmu.c fm33lc0xx_fl_rcc.c fm33lc0xx_fl_rng.c fm33lc0xx_fl_rtc.c fm33lc0xx_fl_spi.c fm33lc0xx_fl_svd.c fm33lc0xx_fl_u7816.c fm33lc0xx_fl_uart.c fm33lc0xx_fl_wwdt.c fm33lc0xx_fl_lcd.c fm33lc0xx_fl_exti.c fm33lc0xx_fl.c
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/FM/FM33xx/Source/Templates/arm/: startup_fm33lc0xx.s
  group Application/MF-Config
    ../MF-config/: mf_config.c mf_config.h
  group Application/Interflow
    ../Interflow/: MQTT_JSON.c MQTT_JSON.h NumberBaseLic.c NumberBaseLic.h StrLib.c StrLib.h 4G_Module.c 4G_Module.h NetProt_Module.c NetProt_Module.h ATCmd_FunctionSum.c ATCmd_FunctionSum.h CH340_LPUart1.c CH340_LPUart1.h
  group Application/User
    ../User/: ADC.c ADC.h AT24C0256.c AT24C0256.h AT45DB041.c BSTim.c BSTim.h CRC16.c Define.c Define.h Gpio.c Gpio.h GpTim.c ImmediatelyReading.c ImmediatelyReading.h LPTim32.c LPTim32.h LPUart.c LPUart.h main.c main.h RTC.c RTC.h RX8025T.c RX8025T.h TimerCopyReading.c TimerCopyReading.h TimerMainReading.c TimerMainReading.h Uart.c Uart.h UpData.c UpData.h UpDataProtocol.c UpDataProtocol.h
